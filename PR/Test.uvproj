# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Test
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 c8051F020.h FO-M3.c FO-M3.h FCT_03A.c FO-M4.c FO-M4.h main.c FCT_05A.h FCT_03A.h main.h FCT_05A.c
